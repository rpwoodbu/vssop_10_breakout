# Repository rpwoodbu/vssop_10_breakout

## KiCad design vssop_10_breakout.kicad_pcb

Board: 2 copper layers, 10.2 x 12.7 mm, 3 parts (2 on the bottom side), 10 nets.

Parts:
J1, J2: CONN_01X05; Pin_Header_Straight_1x05_Pitch2.54mm
U1: VSSOP; VSSOP-10_3x3mm_Pitch0.5mm

Connections:
unnamed: J1.1, U1.1
unnamed: J1.2, U1.2
unnamed: J1.3, U1.3
unnamed: J1.4, U1.4
unnamed: J1.5, U1.5
unnamed: J2.1, U1.10
unnamed: J2.2, U1.9
unnamed: J2.3, U1.8
unnamed: J2.4, U1.7
unnamed: J2.5, U1.6

## Commit log

2017-07-04 Initial commit. Basic layout complete.
2017-07-04 Fixup silkscreen layers.
2017-07-04 Add a footprint for VSSOP-10
2017-07-04 Replace VSSOP footprint with custom one
2017-07-05 Redo layout with new footprint.
2017-07-05 Make back silkscreen more interesting.
